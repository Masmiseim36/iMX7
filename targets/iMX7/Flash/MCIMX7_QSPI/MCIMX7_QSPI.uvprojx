# Keil uVision project MCIMX7_QSPI.uvprojx, settings and files
target QSPI1A_32MB (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MCIMX7D:Cortex-M4 NXP
  pack: Keil.iMX7D_DFP.1.4.0-dev0
  cpu: IRAM(0x20000000,0x00008000) IRAM2(0x1FFF0000,0x00008000) IROM(0x00000000,0x00008000) CPUTYPE("Cortex-M4") CLOCK(12000000)
  output: flash_algo
  AfterMake: cmd.exe /C copy .\Objects\flash_algo.axf ..\MCIMX7_QSPI1A_32.FLM
  c flags: uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: QSPI1 QSPI1A_32MB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x1fff0000 size 0x8000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Funcitions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Device Driver
    ./: fsl_qspi.c
